# Keil uVision project cmsis_dsp.uvprojx, settings and files
target cmsis_dsp (6140000::V6.14::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cmsis_dsp +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f403a_407_board;..\mdk_v5;..\..\..\..\..\..\libraries\cmsis\dsp\include;..\..\..\..\..\..\libraries\cmsis\dsp\PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
  group bsp
    ../../../../../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f403a_407_gpio.c at32f403a_407_crm.c at32f403a_407_usart.c at32f403a_407_misc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group cmsis_dsp
    ../../../../../../libraries/cmsis/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/BayesFunctions/: BayesFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/CommonTables/: CommonTables.c
    ../../../../../../libraries/cmsis/dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/ControllerFunctions/: ControllerFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/DistanceFunctions/: DistanceFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/FilteringFunctions/: FilteringFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/MatrixFunctions/: MatrixFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/SupportFunctions/: SupportFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/SVMFunctions/: SVMFunctions.c
    ../../../../../../libraries/cmsis/dsp/Source/TransformFunctions/: TransformFunctions.c
  group readme
    ../: readme.txt
target fpu_disable (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.2
  cpu: as above
  output: fpu_disable +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f403a_407_board;..\mdk_v5
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
