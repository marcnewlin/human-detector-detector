# IAR project extend_sram.ewp, settings and files
configuration extend_sram_224k (ARM)
  General.OGChipSelectEditMenu: AT32F403AVGT7_v2 ArteryTek -AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403AVGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1; EXTEND_SRAM=0xFE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32f403a_407_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: extend_sram.srec
  ILINK.IlinkOutputFile: extend_sram_224k.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration extend_sram_96k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F403AVGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1; EXTEND_SRAM=0xFF
  ILINK.IlinkOutputFile: extend_sram_96k.out
  group bsp
    ../../../../../at32f403a_407_board/: at32f403a_407_board.c
  group cmsis
    ./: startup_at32f403a_407_ext_ram.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
