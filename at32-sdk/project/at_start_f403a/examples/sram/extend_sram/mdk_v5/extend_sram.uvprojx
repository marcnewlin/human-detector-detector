# Keil uVision project extend_sram.uvprojx, settings and files
target set_sram_224k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: extend_sram_224k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1,EXTEND_SRAM=0xFE
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f403a_407_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
  group bsp
    ../../../../../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ./: startup_at32f403a_407_ext_ram.s
  group readme
    ../: readme.txt
target set_sram_96k (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.0
  cpu: as above
  output: extend_sram_96k +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1,EXTEND_SRAM=0xFF
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
