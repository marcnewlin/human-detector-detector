<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\freertos_demo.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>freertos_demo</project>
                <configuration>at_start_f403a</configuration>
            </member>
            <member>
                <project>freertos_demo</project>
                <configuration>at_start_f407</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
