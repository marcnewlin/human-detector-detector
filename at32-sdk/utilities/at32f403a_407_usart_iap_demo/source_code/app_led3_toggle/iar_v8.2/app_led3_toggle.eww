<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app_led3_toggle.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>app_led3_toggle</project>
                <configuration>at_start_f403a</configuration>
            </member>
            <member>
                <project>app_led3_toggle</project>
                <configuration>at_start_f407</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
