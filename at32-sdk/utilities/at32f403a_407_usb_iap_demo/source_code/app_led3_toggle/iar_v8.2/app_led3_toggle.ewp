# IAR project app_led3_toggle.ewp, settings and files
configuration at_start_f403a (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403AVGT7_v2 ArteryTek -AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403AVGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f403a_407_board; ..\..\..\..\..\middlewares\usbd_class\hid_iap; ..\..\..\..\..\middlewares\usbd_drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f403a_app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F403AxG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f407 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F407VGT7_v2 ArteryTek -AT32F407VGT7
  ICCARM.CCDefines: AT32F407VGT7; USE_STDPERIPH_DRIVER; AT_START_F407_V1
  OBJCOPY.OOCOutputFile: at32f407_app_led3_toggle.bin
  ILINK.IlinkIcfFile: AT32F407xG.icf
  group bsp
    ../../../../../project/at32f403a_407_board/: at32f403a_407_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f403a_407.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_usb.c
  group readme
    ../: readme.txt
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group usbd_drivers
    ../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c hid_iap_user.c main.c
