<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootloader.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>bootloader</project>
                <configuration>at_start_f403a</configuration>
            </member>
            <member>
                <project>bootloader</project>
                <configuration>at_start_f407</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
